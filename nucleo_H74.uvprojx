# Keil uVision project nucleo_H74.uvprojx, settings and files
target stm32 (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: nucleo_H74 +hex
  BeforeMake: .\H74_fw\script\pre_build.bat .\H74_fw\build.inc .\H74_fw\build.h ..\.git
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ./H74_fw;./H74_fw/core;./H74_fw/driver;./H74_fw/cp_srv;./H74_fw/daq_srv;./H74_fw/share
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application
    ./H74_fw/core/: cli.c cli.h cli_defs.h cli_lib.c cli_lib.h cm.c cm.h io.h lib.c lib.h msg_str.h rec_types.h user_main.c user_main.h
    ./H74_fw/cp_srv/: cp_hal.c cp_hal.h cp_msg.h cp_srv.c cp_srv.h
    ./H74_fw/daq_srv/: daq_hal.c daq_hal.h daq_msg.h daq_srv.c daq_srv.h
    ./H74_fw/driver/: adc.c adc.h uart.c uart.h xlprint.c xlprint.h
    ./H74_fw/share/: cm_const.h cm_msg.h ee_type.h fw_cfg.h type.h
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:TIM 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.9.0
