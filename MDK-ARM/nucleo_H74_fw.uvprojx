# Keil uVision project nucleo_H74_fw.uvprojx, settings and files
target nucleo_H74_fw (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: nucleo_H74_fw +hex
  BeforeMake: ..\H74_fw\script\pre_build.bat ..\H74_fw\build.inc ..\H74_fw\build.h ..\.git
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../H74_fw;../H74_fw/core;../H74_fw/driver;../H74_fw/cp_srv;../H74_fw/daq_srv;../H74_fw/share
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../H74_fw/core/: cli.c cli.h cli_defs.h cli_lib.c cli_lib.h cm.c cm.h io.h lib.c lib.h msg_str.h rec_types.h user_main.c user_main.h
    ../H74_fw/cp_srv/: cp_hal.c cp_hal.h cp_msg.h cp_srv.c cp_srv.h
    ../H74_fw/daq_srv/: daq_hal.c daq_hal.h daq_msg.h daq_srv.c daq_srv.h
    ../H74_fw/driver/: adc.c adc.h uart.c uart.h xlprint.c xlprint.h
    ../H74_fw/share/: cm_const.h cm_msg.h ee_type.h fw_cfg.h type.h
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
software components: CMSIS:CORE 5.6.0
